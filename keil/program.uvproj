# Keil uVision project program.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: program +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Keil_v5\C51\INC\Atmel
  group Source Group 1
    ./: main.c DS18B20.c DS18B20.h delay1ms.c delay1ms.h TM1637.c TM1637.h
